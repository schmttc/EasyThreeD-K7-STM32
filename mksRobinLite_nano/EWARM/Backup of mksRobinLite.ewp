# IAR project Backup of mksRobinLite.ewp, settings and files
configuration mksRobinLite (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103ZC ST STM32F103ZC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xE; MKS_ROBIN; MARLIN; __arm__; USE_MKS_WIFI
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ../Inc; ../Src; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/STM32F10x_StdPeriph_Driver/Inc; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include; ../Drivers/BSP/STM32MKS-3dPrinter; ../Drivers/BSP/Components/Common; ../Drivers/BSP/Components/l6474; ../Drivers/BSP/Components/at24cxx; ../Drivers/BSP/Components/w25qxx; ../Drivers/BSP/MotorControl; ../Middlewares/Third_Party/FatFs/src; ../Middlewares/Third_Party/FatFs/src/drivers; ../Middlewares/Third_Party/Marlin; ../Middlewares/Third_Party/u8glib_arm_v1.17/src; ../Middlewares/arduino; ../Middlewares/arduino/avr; ../Inc/Logo
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: mksLite.bin
  ILINK.IlinkOutputFile: mksLite.out
  ILINK.IlinkIcfFile: stm32f103xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/iar/: startup_stm32f103xe.s
  group Application/User
    ../Src/: adc.c dma.c gpio.c i2c.c main.cpp nano.cpp spi.c stm32f1xx_hal_msp.c stm32f1xx_it.cpp tim.c usart.c wifi_module .cpp wifi_upload.cpp
  group Drivers/BSP/Components/at24cxx
    ../Drivers/BSP/Components/at24cxx/: at24cxx.cpp
  group Drivers/BSP/Components/w25qxx
    ../Drivers/BSP/Components/w25qxx/: spi_flash.c
  group Drivers/BSP/STM32MKS-3dPrinter
    ../Drivers/BSP/STM32MKS-3dPrinter/: stm32f1xx_3dprinter_misc.c stm32f1xx_3dprinter_uart.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Drivers/STM32F10x_StdPeriph_Driver
    ../Drivers/STM32F10x_StdPeriph_Driver/src/: stm32f10x_spi.c stm32f10x_usart.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Middlewares/arduino
    ../Middlewares/arduino/: Print.cpp
  group Middlewares/Marlin
    ../Middlewares/Third_Party/Marlin/: blinkm.cpp cardreader.cpp configuration_store.cpp dac_mcp4728.cpp digipot_mcp4451.cpp endstops.cpp G26_Mesh_Validation_Tool.cpp hex_print_routines.cpp least_squares_fit.cpp M100_Free_Mem_Chk.cpp Marlin_main.cpp MarlinSerial.cpp mesh_bed_leveling.cpp planner.cpp planner_bezier.cpp printcounter.cpp qr_solve.cpp Sd2Card.cpp SdBaseFile.cpp SdFatUtil.cpp SdFile.cpp SdVolume.cpp serial.cpp servo.cpp stepper.cpp stepper_dac.cpp stepper_indirection.cpp stopwatch.cpp temperature.cpp twibus.cpp ubl.cpp ubl_G29.cpp ubl_motion.cpp ultralcd.cpp utility.cpp vector_3.cpp watchdog.cpp
  group Middlewares/U8glib
    ../Middlewares/Third_Party/u8glib_arm_v1.17/src/: chessengine.c u8g.h u8g_bitmap.c u8g_circle.c u8g_clip.c u8g_com_api.c u8g_com_api_16gr.c u8g_com_i2c.c u8g_com_io.c u8g_com_null.c u8g_com_raspberrypi_hw_spi.c u8g_com_raspberrypi_ssd_i2c.c u8g_cursor.c u8g_delay.c u8g_dev_a2_micro_printer.c u8g_dev_flipdisc_2x7.c u8g_dev_gprof.c u8g_dev_ht1632.c u8g_dev_ili9325d_320x240.c u8g_dev_ks0108_128x64.c u8g_dev_lc7981_160x80.c u8g_dev_lc7981_240x128.c u8g_dev_lc7981_240x64.c u8g_dev_lc7981_320x64.c u8g_dev_ld7032_60x32.c u8g_dev_null.c u8g_dev_pcd8544_84x48.c u8g_dev_pcf8812_96x65.c u8g_dev_sbn1661_122x32.c u8g_dev_ssd1306_128x32.c u8g_dev_ssd1306_128x64.c u8g_dev_ssd1309_128x64.c u8g_dev_ssd1322_nhd31oled_bw.c u8g_dev_ssd1322_nhd31oled_gr.c u8g_dev_ssd1325_nhd27oled_bw.c u8g_dev_ssd1325_nhd27oled_bw_new.c u8g_dev_ssd1325_nhd27oled_gr.c u8g_dev_ssd1325_nhd27oled_gr_new.c u8g_dev_ssd1327_96x96_gr.c u8g_dev_ssd1351_128x128.c u8g_dev_st7565_64128n.c u8g_dev_st7565_dogm128.c u8g_dev_st7565_dogm132.c u8g_dev_st7565_lm6059.c u8g_dev_st7565_lm6063.c u8g_dev_st7565_nhd_c12832.c u8g_dev_st7565_nhd_c12864.c u8g_dev_st7687_c144mvgd.c u8g_dev_st7920_128x64.c u8g_dev_st7920_192x32.c u8g_dev_st7920_202x32.c u8g_dev_t6963_128x128.c u8g_dev_t6963_128x64.c u8g_dev_t6963_240x128.c u8g_dev_t6963_240x64.c u8g_dev_tls8204_84x48.c u8g_dev_uc1601_c128032.c u8g_dev_uc1608_240x128.c u8g_dev_uc1608_240x64.c u8g_dev_uc1610_dogxl160.c u8g_dev_uc1611_dogm240.c u8g_dev_uc1611_dogxl240.c u8g_dev_uc1701_dogs102.c u8g_dev_uc1701_mini12864.c u8g_ellipse.c u8g_font.c u8g_font_data.c u8g_line.c u8g_ll_api.c u8g_page.c u8g_pb.c u8g_pb14v1.c u8g_pb16h1.c u8g_pb16h2.c u8g_pb16v1.c u8g_pb16v2.c u8g_pb32h1.c u8g_pb8h1.c u8g_pb8h1f.c u8g_pb8h2.c u8g_pb8h8.c u8g_pb8v1.c u8g_pb8v2.c u8g_pbxh16.c u8g_pbxh24.c u8g_polygon.c u8g_rect.c u8g_rot.c u8g_scale.c u8g_state.c u8g_u16toa.c u8g_u8toa.c u8g_virtual_screen.c U8glib.cpp
